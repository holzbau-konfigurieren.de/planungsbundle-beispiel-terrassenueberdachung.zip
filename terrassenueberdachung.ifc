Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Holzbau-Konfigurator - unverbindliches Vorschaumodell, nicht fuer Ausfuehrung. Kein Standsicherheitsnachweis, Statik- und Fachpruefung erforderlich. Fehler bitte an info@holzbau-konfigurator.de melden.
File name: terrassenueberdachung.ifc
Time: 2026-10-01T12:23:55
Made in: Carport IFC Generator 1.0
Authorization: q-tm8afv-17155424

# IfcProject, Terrassenueberdachung
Description: Unverbindliches Vorschaumodell aus Holzbau-Konfigurator. Nicht fuer Ausfuehrung. Kein Standsicherheitsnachweis, Statik- und Fachpruefung erforderlich. Fehler bitte an info@holzbau-konfigurator.de melden. [q-tm8afv-17155424]

# IfcMember: Gratsparren
In: Erdgeschoss
Type - ElementType: Gratsparren; PredefinedType: RAFTER
Material: KVH
Qto_MemberBaseQuantities - Length: 6.11107 m; CrossSectionArea: 0.028 m2; OuterSurfaceArea: 4.64442 m2; GrossVolume: 0.17111 m3

# IfcMember: Pfette (2)
In: Erdgeschoss
Type - ElementType: Pfette; PredefinedType: PURLIN
Material: KVH
Qto_MemberBaseQuantities - CrossSectionArea: 0.056 m2
Name | Length (m) | OuterSurfaceArea (m2) | GrossVolume (m3)
Pfette | 6.3 | 6.804 | 0.3528
Pfette | 7.16 | 7.7328 | 0.40096

# IfcMember: Pfosten (3)
In: Erdgeschoss
Type - ElementType: Pfosten; PredefinedType: POST
Material: KVH
Qto_MemberBaseQuantities - Length: 2.6 m; CrossSectionArea: 0.0196 m2; OuterSurfaceArea: 1.456 m2; GrossVolume: 0.05096 m3

# IfcMember: Schifter (10)
In: Erdgeschoss
Type - ElementType: Schifter; PredefinedType: RAFTER
Material: KVH
Qto_MemberBaseQuantities - CrossSectionArea: 0.016 m2
Name | Length (m) | OuterSurfaceArea (m2) | GrossVolume (m3)
2 x Schifter | 3.66904 | 2.05466 | 0.058705
2 x Schifter | 2.99582 | 1.67766 | 0.047933
2 x Schifter | 2.3226 | 1.30066 | 0.037162
2 x Schifter | 1.64939 | 0.923656 | 0.02639
2 x Schifter | 0.976167 | 0.546653 | 0.015619

# IfcMember: Sparren (11)
In: Erdgeschoss
Type - ElementType: Sparren; PredefinedType: RAFTER
Material: KVH
Qto_MemberBaseQuantities - Length: 4.34226 m; CrossSectionArea: 0.016 m2; OuterSurfaceArea: 2.43167 m2; GrossVolume: 0.069476 m3

# IfcMember: Wandpfette (2)
In: Erdgeschoss
Type - ElementType: Wandpfette; PredefinedType: PURLIN
Material: KVH
Qto_MemberBaseQuantities - CrossSectionArea: 0.056 m2
Name | Length (m) | OuterSurfaceArea (m2) | GrossVolume (m3)
Wandpfette | 2.3 | 2.484 | 0.1288
Wandpfette | 3.23 | 3.4884 | 0.18088
